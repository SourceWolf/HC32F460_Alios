# Keil uVision project HC32F460_Alios_Example.uvprojx, settings and files
target AliOS_Example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.0
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IRAM3(0x20010000,0x10000) IRAM4(0x20020000,0x07000) IRAM5(0x200F0000,0x01000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HC32F460_Alios_Example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,AOS_KV,CONFIG_NO_TCPIP,__TARGET_FPU_VFP
  c misc: --diag_suppress=186,66
  c include: ..\Alios\include;..\Alios\core\include;..\Alios\aos;..\Alios\core;..\Alios;..\aos;..\App;..\armlibc\sys;..\armlibc;..\armlibc\RVMDK;..\certificate_test;..\certificate_test\nanotest;..\common;..\driver\inc;..\FileSystem\inc;..\PeripheralDriver;..\Port;..\aos_rhino
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group App
    ../App/: sys_init.c main.c sys_init.h
  group common
    ../common/MDK/: startup_hc32f46x.s
    ../common/: system_hc32f46x.c
  group Kernel\vcall
    ../aos_rhino/: aos_rhino_kv.c
  group Kernel\core
    ../Alios/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group Port\m4
    ../Port/: k_types.h port.h port_c.c port_s.S
  group aos
    ../aos/: soc_impl.c
  group certificate_test
    ../certificate_test/: rhino_test_nano.c
    ../certificate_test/nanotest/: cut.c
  group armlibc
    ../armlibc/: armcc_libc.c
  group ddl_lib
    ../driver/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group hardware
    ../PeripheralDriver/: System_Clk.c System_Clk.h system_clk_cfg.h
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
