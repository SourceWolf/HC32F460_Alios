<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HC32F460_Alios.ewp</path>
    </project>
    <batchBuild />
</workspace>
