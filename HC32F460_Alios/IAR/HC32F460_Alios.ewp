# IAR project HC32F460_Alios.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32F460PETB HDSC HC32F460PETB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HC32F46x; USE_DEVICE_DRIVER_LIB; __TARGET_FPU_VFP; __FPU_PRESENT=1; CONFIG_NO_TCPIP
  ICCARM.CCIncludePath2: ..\Alios\include; ..\Alios\core\include; ..\Alios\aos; ..\Alios\core; ..\Alios; ..\aos; ..\App; ..\certificate_test; ..\certificate_test\nanotest; ..\common; ..\driver\inc; ..\FileSystem\inc; ..\PeripheralDriver; ..\Port; ..\aos_rhino; $TOOLKIT_DIR$\CMSIS\Core\Include; ..\libc\compilers\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HC32F460_Alios.hex
  ILINK.IlinkOutputFile: HC32F460_Alios.out
  ILINK.IlinkIcfFile: ..\flashloader\HC32F46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group aos
    ../aos/: soc_impl.c
  group App
    ../App/: main.c sys_init.c sys_init.h
  group Certificate_test
    ../certificate_test/nanotest/: cut.c
    ../certificate_test/: rhino_test_nano.c
  group common
    ../common/: ddl_config.h hc32_common.h hc32_ddl.h HC32F46x.h startup_hc32f46x.s system_hc32f46x.c system_hc32f46x.h
  group ddl_lib
    ../driver/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group hardware
    ../PeripheralDriver/: System_Clk.c System_Clk.h system_clk_cfg.h
  group Kernel\core
    ../Alios/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group Kernel\vcall
    ../aos_rhino/: aos_rhino_kv.c
  group Port\M4
    ../Port/: k_types.h port.h port_c.c
    ../Port/IAR/: port_s.S
